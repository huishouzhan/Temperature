# Keil uVision project B_Core.uvprojx, settings and files
target B_CoreV1.0 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: B_Core +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\App;.\Bsp;.\uCOS-III\CPU;.\uCOS-III\LIB;.\uCOS-III\OS;.\STM32\LIB\inc;.\STM32\M3;.\ModBus;.\ModBus\ascii;.\ModBus\functions;.\ModBus\include;.\ModBus\Port;.\ModBus\rtu;.\ModBus\tcp
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ./App/: APP.c
  group Bsp
    ./Bsp/: bsp.c myiic.c stmflash.c
  group STM32/CORE
    ./STM32/StartUp/: startup_stm32f10x_md.s
    ./STM32/M3/: core_cm3.c stm32f10x_it.c system_stm32f10x.c
  group STM32/LIB
    ./STM32/LIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c
  group uCOS-III/CPU
    ./uCOS-III/CPU/: cpu_c.c cpu_core.c cpu_a.s
  group uCOS-III/LIB
    ./uCOS-III/LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c lib_mem_a.asm
  group uCOS-III/OS
    ./uCOS-III/OS/: os_app_hooks.c os_cfg_app.c os_core.c os_cpu_c.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c os_cpu_a.s
  group ModBus
    ./ModBus/: mb.c
  group ModBus/Port
    ./ModBus/Port/: portevent.c portserial.c porttimer.c
  group ModBus/Funtions
    ./ModBus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group ModBus/RTU
    ./ModBus/rtu/: mbcrc.c mbrtu.c
  group ModBus/Ascii
    ./ModBus/ascii/: mbascii.c
  group ModBus/TCP
    ./ModBus/tcp/: mbtcp.c
  group ReadMe
    ./ReadMe/: ReadMe.txt
